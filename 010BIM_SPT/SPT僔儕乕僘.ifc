Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-07-13T19:27:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - 代替 UI 17.21.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 13 19:27:54 2022 * Host: 023-KYOYA-02 * Database: C:\Users\kozo-keikaku\AppData\Local\Temp\{32082AF2-9F29-4E1A-A389-E05C597E2CDA}\ifc * Database version: 5507 * Database creation date: Wed Jul 13 19:27:53 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 13 19:27:54 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 13 19:27:54 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, レベル 1
LongName: レベル 1; Elevation: 0 mm

# IfcBuildingElementProxy: SPT251, ISベース_SPT:SPT251:24990
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SPT251
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SPT301, ISベース_SPT:SPT301:25131
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SPT301
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SPT302, ISベース_SPT:SPT302:25262
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SPT302
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SPT303, ISベース_SPT:SPT303:37139
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SPT303
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SPT351, ISベース_SPT:SPT351:25139
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SPT351
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SPT352, ISベース_SPT:SPT352:25263
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SPT352
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SPT401, ISベース_SPT:SPT401:25147
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SPT401
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SPT451, ISベース_SPT:SPT451:25155
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SPT451
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
